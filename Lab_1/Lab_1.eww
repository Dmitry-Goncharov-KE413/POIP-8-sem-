<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Lab_1 (Timers).ewp</path>
    </project>
    <batchBuild />
</workspace>
