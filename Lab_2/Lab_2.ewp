# IAR project Lab_2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RC ST STM32F411RC
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: D:\POIP\CortexLib\AbstractHardware\Registers; D:\POIP\CortexLib\AbstractHardware\Registers\STM32F411; D:\POIP\CortexLib\AbstractHardware\Registers\STM32F411\FieldValues; D:\POIP\CortexLib\Common; D:\POIP\POIP-8-sem-\Lab_2\Components; D:\POIP\POIP-8-sem-\Lab_2\Components\Button; D:\POIP\POIP-8-sem-\Lab_2\Components\LED; D:\POIP\POIP-8-sem-\Lab_2\Components\Observer; D:\POIP\POIP-8-sem-\Lab_2\Hardware; D:\POIP\POIP-8-sem-\Lab_2\Hardware\Pin; D:\POIP\POIP-8-sem-\Lab_2\Modes; D:\POIP\POIP-8-sem-\Lab_2\Modes\AllMode; D:\POIP\POIP-8-sem-\Lab_2\Modes\ChessMode; D:\POIP\POIP-8-sem-\Lab_2\Modes\Garland; D:\POIP\POIP-8-sem-\Lab_2\Modes\SlideMode; D:\POIP\POIP-8-sem-\Lab_2\Modes\TreeMode; D:\POIP\CortexLib\AbstractHardware\Registers\CortexM4; D:\POIP\CortexLib\AbstractHardware\Registers\CortexM4\FieldValues; D:\POIP\CortexLib\AbstractHardware\InterruptHandler
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.cpp startup.cpp
  group Components/Button
    Components/Button/: Button.cpp IButton.h IPinReadable.h
  group Components/LED
    Components/LED/: ILed.h Led.cpp
  group Components/Observer
    Components/Observer/: IButtonObserver.h IObservable.h
  group Hardware/Pin
    Hardware/Pin/: ipin.h pin.h pinconfig.h
  group Modes/AllMode
    Modes/AllMode/: AllMode.cpp
  group Modes/ChessMode
    Modes/ChessMode/: ChessMode.cpp
  group Modes/Garland
    Modes/Garland/: Garland.h IMode.h
  group Modes/SlideMode
    Modes/SlideMode/: SlideMode.cpp
  group Modes/TreeMode
    Modes/TreeMode/: TreeMode.cpp
