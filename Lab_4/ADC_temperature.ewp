# IAR project ADC_temperature.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RC ST STM32F411RC
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: D:\POIP\CortexLib\AbstractHardware\Registers; D:\POIP\CortexLib\AbstractHardware\Registers\STM32F411; D:\POIP\CortexLib\AbstractHardware\Registers\STM32F411\FieldValues; D:\POIP\CortexLib\Common; D:\POIP\POIP-8-sem-\Lab_4\Components; D:\POIP\POIP-8-sem-\Lab_4\Components\Button; D:\POIP\POIP-8-sem-\Lab_4\Components\LED; D:\POIP\POIP-8-sem-\Lab_4\Components\Observer; D:\POIP\POIP-8-sem-\Lab_4\Hardware; D:\POIP\POIP-8-sem-\Lab_4\Hardware\Pin; D:\POIP\POIP-8-sem-\Lab_4\Hardware\Sender; D:\POIP\POIP-8-sem-\Lab_4\Modes; D:\POIP\POIP-8-sem-\Lab_4\Modes\AllMode; D:\POIP\POIP-8-sem-\Lab_4\Modes\ChessMode; D:\POIP\POIP-8-sem-\Lab_4\Modes\Garland; D:\POIP\POIP-8-sem-\Lab_4\Modes\SlideMode; D:\POIP\POIP-8-sem-\Lab_4\Modes\TreeMode; D:\POIP\CortexLib\AbstractHardware\Registers\CortexM4; D:\POIP\CortexLib\AbstractHardware\Registers\CortexM4\FieldValues; D:\POIP\CortexLib\AbstractHardware\InterruptHandler; D:\POIP\CortexLib\AbstractHardware\Uart; D:\POIP\CortexLib\AbstractHardware\Uart\Stm32Fxx; D:\POIP\CortexLib\AbstractHardware\Uart\Stm32Fxx\STM32F411; D:\POIP\POIP-8-sem-\Lab_4\Hardware\ADC; D:\POIP\POIP-8-sem-\Lab_4\Application; D:\POIP\POIP-8-sem-\Lab_4\Application\Parameters; D:\POIP\POIP-8-sem-\Lab_4\Thread; D:\POIP\POIP-8-sem-\Lab_4\CMSIS; D:\POIP\POIP-8-sem-\Lab_4\Common; D:\POIP\POIP-8-sem-\Lab_4\Rtos; D:\POIP\POIP-8-sem-\Lab_4\Rtos\FreeRtos; D:\POIP\POIP-8-sem-\Lab_4\Rtos\FreeRtos\include; D:\POIP\POIP-8-sem-\Lab_4\Rtos\FreeRtos\portable; D:\POIP\POIP-8-sem-\Lab_4\Rtos\FreeRtos\portable\Common; D:\POIP\POIP-8-sem-\Lab_4\Rtos\FreeRtos\portable\IAR; D:\POIP\POIP-8-sem-\Lab_4\Rtos\FreeRtos\portable\IAR\ARM_CM4F; D:\POIP\POIP-8-sem-\Lab_4\Rtos\FreeRtos\portable\MemMang; D:\POIP\POIP-8-sem-\Lab_4\Rtos\wrapper; D:\POIP\POIP-8-sem-\Lab_4\Rtos\wrapper\FreeRtos
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: D:\POIP\POIP-8-sem-\Lab_4\CMSIS; D:\POIP\POIP-8-sem-\Lab_4\Common; D:\POIP\POIP-8-sem-\Lab_4\Rtos; D:\POIP\POIP-8-sem-\Lab_4\Rtos\FreeRtos; D:\POIP\POIP-8-sem-\Lab_4\Rtos\FreeRtos\include; D:\POIP\POIP-8-sem-\Lab_4\Rtos\FreeRtos\portable; D:\POIP\POIP-8-sem-\Lab_4\Rtos\FreeRtos\portable\Common; D:\POIP\POIP-8-sem-\Lab_4\Rtos\FreeRtos\portable\IAR; D:\POIP\POIP-8-sem-\Lab_4\Rtos\FreeRtos\portable\IAR\ARM_CM4F; D:\POIP\POIP-8-sem-\Lab_4\Rtos\FreeRtos\portable\MemMang; D:\POIP\POIP-8-sem-\Lab_4\Rtos\wrapper; D:\POIP\POIP-8-sem-\Lab_4\Rtos\wrapper\FreeRtos
  OBJCOPY.OOCOutputFile: ADC_temperature.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ./: main.cpp startup.cpp
  group Application/Parameters
    Application/Parameters/: IMeasureParameter.h Temperature.cpp
  group CMSIS
    CMSIS/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm3.h core_cm33.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h stm32f411xe.h stm32f4xx.h system_stm32f4xx.h
  group Components/Button
    Components/Button/: Button.cpp IButton.h IPinReadable.h
  group Components/LED
    Components/LED/: ILed.h Led.cpp
  group Components/Observer
    Components/Observer/: IButtonObserver.h IObservable.h
  group Hardware/ADC
    Hardware/ADC/: ADC.cpp IADC.h
  group Hardware/Pin
    Hardware/Pin/: ipin.h pin.h pinconfig.h
  group Hardware/Sender
    Hardware/Sender/: Sender.h
  group Modes/AllMode
    Modes/AllMode/: AllMode.cpp
  group Modes/ChessMode
    Modes/ChessMode/: ChessMode.cpp
  group Modes/Garland
    Modes/Garland/: Garland.h IMode.h
  group Modes/SlideMode
    Modes/SlideMode/: SlideMode.cpp
  group Modes/TreeMode
    Modes/TreeMode/: TreeMode.cpp
  group Rtos/FreeRtos
    Rtos/FreeRtos/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c tasks.c timers.c
  group Rtos/FreeRtos/include
    Rtos/FreeRtos/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group Rtos/FreeRtos/portable/IAR
    Rtos/FreeRtos/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group Rtos/Wrapper
    Rtos/wrapper/: criticalsection.hpp event.hpp eventmode.hpp interruptentry.hpp mailbox.hpp mutex.hpp rtos.hpp thread.hpp
  group Rtos/Wrapper/FreeRtos
    Rtos/wrapper/FreeRtos/: rtosdefs.hpp rtoswrapper.hpp
  group Thread
    Thread/: InSender.cpp OutSender.cpp
